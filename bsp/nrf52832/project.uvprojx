# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-nrf52832 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: NRF52, USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: Libraries/CMSIS/Include;Libraries/nrf52832/Include;applications;.;drivers;../../include;../../libcpu/arm/cortex-m0;../../libcpu/arm/common;../../components/drivers/include;../../components/finsh
  asm define: NRF52, USE_STDPERIPH_DRIVER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup Code
    ./Libraries/nrf52832/Source/templates/: system_nrf52.c
    ./Libraries/nrf52832/Source/templates/arm/: arm_startup_nrf52.s
  group Applications
    ./applications/: application.c startup.c
  group Drivers
    ./drivers/: board.c uart.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c object.c scheduler.c thread.c timer.c mem.c memheap.c mempool.c
  group CORTEX-M4
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/src/: completion.c portal.c ringbuffer.c workqueue.c
  group finsh
    ../../components/finsh/: cmd.c shell.c symbol.c msh_cmd.c msh.c
